File: EDA/Jr PCB/ext_adc.kicad_sch (KiCad schematic)
At the start: 7 parts, among them U6 ADS1115IDGS, U7 ADS1115IDGS

Commit message: Jr +
Parts:
- U6, U7: JLC C37593 -> C468683
